# Keil uVision project TLE9893_2QKW62S_UART_PRINTF.uvprojx, settings and files
target TLE9893_2QKW62S (6210000::V6.21::ARMCLANG)
  device: TLE9893_2QKW62S Infineon
  pack: Infineon.TLE988x_9x_DFP.1.1.0
  cpu: IRAM(0x18000000,0x1C00) IRAM2(0x18002000,0x6000) IROM(0x11000000,0x8000) IROM2(0x12002000,0x3E000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TLE9893_2QKW62S_UART_PRINTF +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\app
  asm misc: --diag_suppress 1609
  memory RVCT4: ROM 0x11000100 size 0x5f00
  memory RVCT5: ROM 0x12002000 size 0x3e000
  memory RVCT9: RAM 0x18000000 size 0x2000
  memory RVCT10: RAM 0x18002000 size 0x5c00
  scatter file: .\RTE\Device\TLE9893_2QKW62S\tle9883_93.sct
  group app
    ./app/: main.c app_jump.c
software components: CMSIS:CORE 5.4.0, Device:ConfigWizard 0.0.0, Device:Startup 0.3.3, Device:TLELib:ADC1 0.4.6, Device:TLELib:ADC2 0.5.3, Device:TLELib:BDRV 0.7.9, Device:TLELib:BOOTROM 0.3.0, Device:TLELib:CSACSC 0.2.5, Device:TLELib:GPIO 0.2.4, Device:TLELib:INT 0.3.1, Device:TLELib:ISR 0.4.9, Device:TLELib:PMU 0.5.4, Device:TLELib:SCU 0.5.3, Device:TLELib:UART 0.5.8, Compiler:I/O:STDOUT 1.2.0
